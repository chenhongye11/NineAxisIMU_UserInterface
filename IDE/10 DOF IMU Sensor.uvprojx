# Keil uVision project 10 DOF IMU Sensor.uvprojx, settings and files
target 10 DOF IMU Sensor (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 10 DOF IMU Sensor
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c include: ..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HardWare\Modbus;..\SRC\HardWare\USART;..\SRC\HardWare\MPU6050;..\SRC\HardWare\HMC5883L;..\SRC\HardWare\BMP180;..\SRC\HardWare\BMP280;..\SRC\Public;..\SRC\STM32F10x_StdPeriph_Driver\inc;..\SRC\System;..\SRC\User;..\SRC\HardWare\I2C;..\SRC\HardWare\IMU;..\SRC\HardWare\MPU9250;..\SRC\HardWare\invMotionSensor;..\SRC\HardWare\ICM20948;..\SRC\STM32_USB-FS-Device_Driver\inc;..\SRC\USB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../SRC/CMSIS/CoreSupport/: core_cm3.c
    ../SRC/CMSIS/DeviceSupport/: startup_stm32f10x_hd.s
  group HardWare
    ../SRC/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c
    ../SRC/HardWare/USART/: USART.c
    ../SRC/HardWare/I2C/: I2C.c
    ../SRC/HardWare/IMU/: IMU.c
    ../SRC/HardWare/ICM20948/: ICM20948.c
    ../SRC/HardWare/Modbus/: Modbus.c
  group Public
    ../SRC/Public/: Public_StdMacros.h Public_StdTypes.h
  group STM32F10x_StdPeriph_Driver
    ../SRC/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_flash.c
  group System
    ../SRC/System/: System.c
  group User
    ../SRC/User/: main.c stm32f10x_it.c system_stm32f10x.c
software components: CMSIS:CORE 5.1.2
